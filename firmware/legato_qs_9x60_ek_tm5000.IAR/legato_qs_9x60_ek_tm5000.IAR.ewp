# IAR project legato_qs_9x60_ek_tm5000.IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.IExtraOptions: --diag_warning Pe144; --diag_suppress Pe144
  ICCARM.CCIncludePath2: ..\src; ..\src\config\lcdc_rgba8888_mxt_9x60_wvga_iar; ..\src\packs\SAM9X60_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS; ../src; ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar; ../src/packs/SAM9X60_DFP; ../src/packs/CMSIS/CMSIS/Core/Include; ../src/packs/CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: lcdc_rgba8888_mxt_9x60_wvga.out
  ILINK.IlinkIcfFile: ..\src\config\lcdc_rgba8888_mxt_9x60_wvga_iar\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/: device_cache.h toolchain_specifics.h definitions.h interrupts.h device.h user.h configuration.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/bsp
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/: legato.h legato_config.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/common
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/common/: legato_color.h legato_common.h legato_error.h legato_math.h legato_pixelbuffer.h legato_rect.h legato_utils.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/core
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/core/: legato_event.h legato_input.h legato_scheme.h legato_state.h legato_stream.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/datastructure
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/datastructure/: legato_array.h legato_list.h legato_rectarray.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/font
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/font/: legato_font.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/: legato_image.h legato_palette.h legato_image_utils.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/raw
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/raw/: legato_imagedecoder_raw.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/jpeg
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/jpeg/: legato_imagedecoder_jpeg.h legato_imagedecoder_jpeg_common.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/png
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/png/: legato_imagedecoder_png.h lodepng.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/memory
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/memory/: legato_fixedheap.h legato_memory.h legato_variableheap.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/renderer
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/renderer/: legato_renderer.h legato_gpu.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/string
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/string/: legato_dynamicstring.h legato_fixedstring.h legato_string.h legato_string_renderer.h legato_stringtable.h legato_tablestring.h legato_stringutils.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/: legato_editwidget.h legato_widget.h legato_widget_skin_classic_common.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/arc
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/arc/: legato_widget_arc.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/bargraph
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/bargraph/: legato_widget_bar_graph.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/button
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/button/: legato_widget_button.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/checkbox
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/checkbox/: legato_widget_checkbox.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circle
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circle/: legato_widget_circle.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circulargauge
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circulargauge/: legato_widget_circular_gauge.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circularslider
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circularslider/: legato_widget_circular_slider.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/drawsurface
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/drawsurface/: legato_widget_drawsurface.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/gradient
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/gradient/: legato_widget_gradient.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/groupbox
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/groupbox/: legato_widget_groupbox.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/image
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/image/: legato_widget_image.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagerotate
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagerotate/: legato_widget_imagerotate.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagescale
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagescale/: legato_widget_imagescale.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagesequence
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagesequence/: legato_widget_imagesequence.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/keypad
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/keypad/: legato_widget_keypad.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/label
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/label/: legato_widget_label.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/line
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/line/: legato_widget_line.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/linegraph
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/linegraph/: legato_widget_line_graph.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/list
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/list/: legato_widget_list.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/listwheel
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/listwheel/: legato_widget_listwheel.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/piechart
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/piechart/: legato_widget_pie_chart.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/progressbar
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/progressbar/: legato_widget_progressbar.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/radialmenu
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/radialmenu/: legato_widget_radial_menu.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/radiobutton
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/radiobutton/: legato_radiobutton_group.h legato_widget_radiobutton.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/rectangle
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/rectangle/: legato_widget_rectangle.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/scrollbar
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/scrollbar/: legato_widget_scrollbar.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/slider
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/slider/: legato_widget_slider.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/textfield
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/textfield/: legato_widget_textfield.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/touchtest
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/touchtest/: legato_widget_touchtest.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/window
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/window/: legato_widget_window.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated/: le_gen_assets.h le_gen_harmony.h le_gen_init.h le_gen_scheme.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated/screen
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated/screen/: le_gen_screen_Screen0.h le_gen_screen_Screen1.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/driver/lcdc
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/driver/: gfx_driver.h
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/driver/controller/lcdc/: drv_gfx_lcdc.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/driver/gfx2d
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/driver/processor/gfx2d/: drv_gfx2d.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/mmu
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/mmu/: plib_mmu.h cp15.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/clk
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/pio
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/aic
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/tc
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/flexcom/twi/master
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/flexcom/twi/master/: plib_flexcom0_twi_master.h plib_flexcom_twi_master_common.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/lcdc
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/lcdc/: plib_lcdc.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/gfx2d
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/gfx2d/: plib_gfx2d.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/driver
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/driver/i2c
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/driver/i2c/: drv_i2c.h drv_i2c_definitions.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/driver/input
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/driver/input/: drv_maxtouch.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/time
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/input
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/input/: sys_input.h sys_input_gesture.h sys_input_keyboard.h sys_input_listener.h sys_input_mouse.h sys_input_touch.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/int
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/cache
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/debug
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/osal
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/instance
    ../src/packs/SAM9X60_DFP/instance/: adc.h aes.h aic.h bsc.h can0.h can1.h classd.h dbgu.h emac0.h emac1.h flexcom0.h flexcom1.h flexcom10.h flexcom11.h flexcom12.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h flexcom8.h flexcom9.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pioa.h piob.h pioc.h piod.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc0.h sdmmc1.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc0.h tc1.h tdes.h trng.h udphs.h uhphs_ehci.h uhphs_ohci.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/: initialization.c interrupts.c cstartup.s vectortrap.s tasks.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/bsp
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/common
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/common/: legato_color.c legato_color_blend.c legato_color_convert.c legato_color_lerp.c legato_color_value.c legato_error.c legato_math.c legato_pixelbuffer.c legato_rect.c legato_utils.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/core
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/core/: legato_event.c legato_input.c legato_scheme.c legato_state.c legato_stream.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/datastructure
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/datastructure/: legato_array.c legato_list.c legato_rectarray.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/font
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/font/: legato_font.c legato_rasterfont_liberationmono1.c legato_rasterfont_liberationmono8.c legato_rasterfont_stream.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/: legato_image.c legato_palette.c legato_image_utils.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/raw
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/raw/: legato_imagedecoder_raw.c legato_imagedecoder_raw_blend.c legato_imagedecoder_raw_convert.c legato_imagedecoder_raw_mask.c legato_imagedecoder_raw_palette_internal.c legato_imagedecoder_raw_palette_stream.c legato_imagedecoder_raw_read_internal.c legato_imagedecoder_raw_read_stream_color.c legato_imagedecoder_raw_read_stream_index.c legato_imagedecoder_raw_read_stream_rlecolor.c legato_imagedecoder_raw_read_stream_rleindex.c legato_imagedecoder_raw_rotate.c legato_imagedecoder_raw_scale.c legato_imagedecoder_raw_setup.c legato_imagedecoder_raw_write.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/jpeg
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/jpeg/: legato_imagedecoder_jpeg.c legato_imagedecoder_jpeg_common.c jidctint.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/png
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/image/png/: legato_imagedecoder_png.c lodepng.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/memory
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/memory/: legato_fixedheap.c legato_memory.c legato_variableheap.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/renderer
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/renderer/: legato_draw.c legato_draw_arc.c legato_draw_line.c legato_draw_rect.c legato_renderer.c legato_gpu.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/string
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/string/: legato_dynamicstring.c legato_fixedstring.c legato_string.c legato_string_renderer.c legato_string_renderer_stream.c legato_stringtable.c legato_tablestring.c legato_stringutils.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/: legato_editwidget.c legato_widget.c legato_widget_skin_classic.c legato_widget_skin_classic_common.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/arc
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/arc/: legato_widget_arc.c legato_widget_arc_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/bargraph
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/bargraph/: legato_widget_bar_graph.c legato_widget_bar_graph_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/button
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/button/: legato_widget_button.c legato_widget_button_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/checkbox
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/checkbox/: legato_widget_checkbox.c legato_widget_checkbox_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circle
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circle/: legato_widget_circle.c legato_widget_circle_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circulargauge
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circulargauge/: legato_widget_circular_gauge.c legato_widget_circular_gauge_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circularslider
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/circularslider/: legato_widget_circular_slider.c legato_widget_circular_slider_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/drawsurface
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/drawsurface/: legato_widget_drawsurface.c legato_widget_drawsurface_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/gradient
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/gradient/: legato_widget_gradient.c legato_widget_gradient_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/groupbox
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/groupbox/: legato_widget_groupbox.c legato_widget_groupbox_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/image
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/image/: legato_widget_image.c legato_widget_image_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagerotate
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagerotate/: legato_widget_imagerotate.c legato_widget_imagerotate_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagescale
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagescale/: legato_widget_imagescale.c legato_widget_imagescale_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagesequence
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/imagesequence/: legato_widget_imagesequence.c legato_widget_imagesequence_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/keypad
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/keypad/: legato_widget_keypad.c legato_widget_keypad_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/label
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/label/: legato_widget_label.c legato_widget_label_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/line
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/line/: legato_widget_line.c legato_widget_line_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/linegraph
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/linegraph/: legato_widget_line_graph.c legato_widget_line_graph_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/list
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/list/: legato_widget_list.c legato_widget_list_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/listwheel
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/listwheel/: legato_widget_listwheel.c legato_widget_listwheel_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/piechart
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/piechart/: legato_widget_pie_chart.c legato_widget_pie_chart_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/progressbar
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/progressbar/: legato_widget_progressbar.c legato_widget_progressbar_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/radialmenu
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/radialmenu/: legato_widget_radial_menu.c legato_widget_radial_menu_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/radiobutton
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/radiobutton/: legato_radiobutton_group.c legato_widget_radiobutton.c legato_widget_radiobutton_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/rectangle
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/rectangle/: legato_widget_rectangle.c legato_widget_rectangle_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/scrollbar
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/scrollbar/: legato_widget_scrollbar.c legato_widget_scrollbar_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/slider
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/slider/: legato_widget_slider.c legato_widget_slider_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/textfield
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/textfield/: legato_widget_textfield.c legato_widget_textfield_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/touchtest
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/touchtest/: legato_widget_touchtest.c legato_widget_touchtest_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/window
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/widget/window/: legato_widget_window.c legato_widget_window_skin_classic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated/: le_gen_globalpalette.c le_gen_harmony.c le_gen_init.c le_gen_scheme.c le_gen_stringtable.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated/font
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated/font/: le_gen_fonts.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated/image
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated/image/: le_gen_images.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated/screen
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/legato/generated/screen/: le_gen_screen_Screen0.c le_gen_screen_Screen1.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/driver/lcdc
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/driver/: gfx_driver.c
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/driver/controller/lcdc/: drv_gfx_lcdc.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/driver/gfx2d
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/gfx/driver/processor/gfx2d/: drv_gfx2d.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/stdio
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/mmu
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/clk
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/pio
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/aic
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/tc
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/flexcom/twi/master
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/flexcom/twi/master/: plib_flexcom0_twi_master.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/lcdc
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/lcdc/: plib_lcdc.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/gfx2d
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/peripheral/gfx2d/: plib_gfx2d.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/driver/i2c
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/driver/i2c/src/: drv_i2c.c drv_i2c_local.h
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/driver/input
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/driver/input/: drv_maxtouch.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/time
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/input
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/input/: sys_input.c sys_input_listener.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/int
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/cache
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/system/cache/: sys_cache.c
  group Harmony3/Linker File
    ../src/config/lcdc_rgba8888_mxt_9x60_wvga_iar/: ddram.icf
